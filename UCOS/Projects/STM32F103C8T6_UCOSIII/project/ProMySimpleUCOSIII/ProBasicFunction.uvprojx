# Keil uVision project ProBasicFunction.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ProBasicFunction +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\CMSIS;.\App;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\UCOSIII\uC_CPU;.\UCOSIII\uCOSIII_Source;.\UCOSIII\uCOSIII_Ports;.\UCOSIII\uC_LIB;.\UCOSIII\uC_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group App
    ./App/: RegisterTemplate.c led.c exti.c time.c iwdg.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_iwdg.c
  group Public
    ./Public/: system.c SysTick.c
  group uC_CPU
    ./UCOSIII/uC_CPU/: cpu.h cpu_def.h
  group uC_CONFIG
    ./UCOSIII/uC_CONFIG/: cpu_cfg.h
